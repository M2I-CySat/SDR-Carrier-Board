# Repository M2I-CySat/SDR-Carrier-Board

File README.md:

# Cysat-1 Software Defined Radio Adapter Board

The Breakout board contains the LNA and band pass filters as well as the SDR used on the satellite. This is a four layer board that has the LNA and RF paths on one side and the FPGA on the other side. A .1" pin header is used to break out the RX/TX lines and an Enable pin to be connected to the PC104 bus and to the rest of the on board electronics.

RF Cables are used to connect the signal from the antenna to the LNAs and a small RF cables is then used to connect the output from the LNA to the FPGA board. RF is present on the board (hence the four layer design) but RF on the FPGA board is only accessible via MCX connectors on the FPGA board itself.

### footprints

This folder contains the footprint libraries for some of the SDR carrier board components
that are used to translate the schematic to a PCB board design in KiCad.

### schematics
This folder contains the SDR carrier "breakout board" KiCad project. In this folder you will
find all of the necessary library and other footprint libraries. This also contains all of 
the necessary files for the KiCad project.

## KiCad design schematics/breakoutBoard/payload_board.kicad_pcb

Board: 2 copper layers, 75.0 x 107.0 mm, 14 parts (0 on the bottom side), 11 nets.

Parts:
H6, H7: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
P1, P2, P3, P4: CONN_02X50; FCI_61083-101400LF
RX: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
SMA1, SMA2: Molex-MMCX-SMD; Molex MMCX SMD 50Ohm
TX: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
scl0: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
sda0, sda1: MountingHole_Pad; MountingHole_2.2mm_M2_Pad

Connections:
/3.3v: J1.2, P1.78, P1.79, P1.80, P2.98, P3.45, P3.46
/5v: J1.1, P1.57, P1.58, P1.59, P1.60, P2.12, P2.57, P2.58, P2.59, P2.60
/ENABLE: H7.1, J1.9, P2.5
/GND: J1.10, P2.78, P2.79, P2.80, P3.5, P3.7, P3.9, P3.11, P3.30, P3.32
/SCL0: J1.6, P2.17, scl0.1
/SCL1: H6.1, J1.8, P2.14
/SDA0: J1.5, P2.19, sda0.1
/SDA1: J1.7, P2.13, sda1.1
/UART_RX: J1.3, P4.16, RX.1
/UART_TX: J1.4, P4.14, TX.1
unnamed: SMA1.1, SMA2.1

## KiCad design breakoutBoard/breakout.kicad_pcb

Parts:
J1: Power_Breakout; Pin_Header_Straight_1x10_Pitch2.54mm
J2: MIO_Breakout; Pin_Header_Straight_1x12_Pitch2.54mm
J3: USB_OTG_Breakout; Pin_Header_Straight_1x06_Pitch2.54mm
J4: Cardedge breakout; Pin_Header_Straight_1x17_Pitch2.54mm
J5: IO_L Breakout; Pin_Header_Straight_1x10_Pitch2.54mm
P1, P2, P3, P4: CONN_02X50; BERGSTAK_100_PIN1_RIGHT
P5: CONN_02X30; MECF-30-01-L-DV-WT_Socket
P7: CONN_02X30; MECF-30-0_-NP-L-DV_Edge

Connections:
3V3_I2C: J1.7, P2.81
+5V: J1.1, J4.1, P3.57, P3.58, P3.59, P3.60, P4.12, P4.57, P4.58, P4.59, P4.60, P5.33, P5.34, P5.37, P5.38, P7.33, P7.34, P7.37, P7.38
AUXADC: P2.7
AUXDAC1: P2.8
AUXDAC2: P2.10
Carrier_Reset: P3.6
FPGA_DONE: J4.16, P3.8, P5.58, P7.58
FPGA_VBATT: J1.3, P3.7
GPO_0: P2.1
GPO_1: P2.2
GPO_2: P2.3
GPO_3: P2.4
IO_00_33_JX1: P3.9
IO_L01_33_JX1_N: J5.10, P3.37
IO_L01_33_JX1_P: J5.9, P3.35
IO_L16_33_JX1_N: J5.2, P3.13
IO_L16_33_JX1_P: J5.1, P3.11
IO_L18_33_JX1_N: J5.4, P3.19
IO_L18_33_JX1_P: J5.3, P3.17
IO_L20_33_JX1_N: J5.6, P3.25
IO_L20_33_JX1_P: J5.5, P3.23
IO_L22_33_JX1_N: J5.8, P3.31
IO_L22_33_JX1_P: J5.7, P3.29
JTAG_TCK: P3.1
JTAG_TDI: P3.4
JTAG_TDO: P3.3
JTAG_TMS: P3.2
JX_VCCO_12: J1.4, P3.78, P3.79, P3.80
JX_VCCO_13: J1.6, P1.45, P1.46, P4.98
JX_VCCO_33_34: J1.5, P4.78, P4.79, P4.80
MIO0: J2.11, J4.9, P2.97, P5.9, P7.9
MIO10: J2.8, J4.12, P2.87, P5.25, P7.25
MIO11: J2.2, J4.6, P2.88, P5.26, P7.26
MIO12: J2.1, J4.7, P2.86, P5.30, P7.30
MIO13: J2.9, J4.11, P2.91, P5.17, P7.17
MIO14: J2.10, J4.10, P2.93, P5.13, P7.13
MIO15: J2.7, J4.13, P2.85, P5.29, P7.29
MIO46: J2.3, J4.5, P2.92, P5.18, P7.18
MIO47: J2.4, J4.4, P2.94, P5.14, P7.14
MIO48: J2.12, J4.8, P2.99, P5.5, P7.5
MIO49: J2.5, J4.3, P2.98, P5.10, P7.10
MIO51: J2.6, J4.2, P2.100, P5.6, P7.6
PG_1P8V: P4.10
PG_MODULE: J4.15, P4.11, P5.53, P7.53
PWR_ENABLE: J1.2, J4.14, P3.5, P5.57, P7.57
USB_ID: J3.1, P1.63
USB_OTG_N: J3.3, P1.69
USB_OTG_P: J3.2, P1.67
USB_VBUS_OTG: J3.5, P1.68
VDDA_GPO_PWR: P2.9

Notes on the sheet:
JX3
JX4
JX1
JX2
<-Might need to remove

Parts:
J1: Power_Breakout; Pin_Header_Straight_1x10_Pitch2.54mm
J2: MIO_Breakout; Pin_Header_Straight_1x12_Pitch2.54mm
J3: USB_OTG_Breakout; Pin_Header_Straight_1x06_Pitch2.54mm
J4: Cardedge breakout; Pin_Header_Straight_1x17_Pitch2.54mm
P1, P2, P3, P4: CONN_02X50; BERGSTAK_100_PIN1_RIGHT
P5: CONN_02X30; MECF-30-01-L-DV-WT_Socket
P7: CONN_02X30; MECF-30-0_-NP-L-DV_Edge

Connections:
3V3_I2C: J1.7, P2.81
+5V: J1.1, J4.1, P3.57, P3.58, P3.59, P3.60, P4.12, P4.57, P4.58, P4.59, P4.60, P5.33, P5.34, P5.37, P5.38, P7.33, P7.34, P7.37, P7.38
AUXADC: P2.7
AUXDAC1: P2.8
AUXDAC2: P2.10
Carrier_Reset: P3.6
FPGA_DONE: J4.16, P3.8, P5.58, P7.58
FPGA_VBATT: J1.3, P3.7
GPO_0: P2.1
GPO_1: P2.2
GPO_2: P2.3
GPO_3: P2.4
IO_00_33_JX1: P3.9
IO_L01_33_JX1_N: P3.37; also elsewhere on the board
IO_L01_33_JX1_P: P3.35; also elsewhere on the board
IO_L16_33_JX1_N: P3.13; also elsewhere on the board
IO_L16_33_JX1_P: P3.11; also elsewhere on the board
IO_L18_33_JX1_N: P3.19; also elsewhere on the board
IO_L18_33_JX1_P: P3.17; also elsewhere on the board
IO_L20_33_JX1_N: P3.25; also elsewhere on the board
IO_L20_33_JX1_P: P3.23; also elsewhere on the board
IO_L22_33_JX1_N: P3.31; also elsewhere on the board
IO_L22_33_JX1_P: P3.29; also elsewhere on the board
JTAG_TCK: P3.1
JTAG_TDI: P3.4
JTAG_TDO: P3.3
JTAG_TMS: P3.2
JX_VCCO_12: J1.4, P3.78, P3.79, P3.80
JX_VCCO_13: J1.6, P1.45, P1.46, P4.98
JX_VCCO_33_34: J1.5, P4.78, P4.79, P4.80
MIO0: J2.11, J4.9, P2.97, P5.9, P7.9
MIO10: J2.8, J4.12, P2.87, P5.25, P7.25
MIO11: J2.2, J4.6, P2.88, P5.26, P7.26
MIO12: J2.1, J4.7, P2.86, P5.30, P7.30
MIO13: J2.9, J4.11, P2.91, P5.17, P7.17
MIO14: J2.10, J4.10, P2.93, P5.13, P7.13
MIO15: J2.7, J4.13, P2.85, P5.29, P7.29
MIO46: J2.3, J4.5, P2.92, P5.18, P7.18
MIO47: J2.4, J4.4, P2.94, P5.14, P7.14
MIO48: J2.12, J4.8, P2.99, P5.5, P7.5
MIO49: J2.5, J4.3, P2.98, P5.10, P7.10
MIO51: J2.6, J4.2, P2.100, P5.6, P7.6
PG_1P8V: P4.10
PG_MODULE: J4.15, P4.11, P5.53, P7.53
PWR_ENABLE: J1.2, J4.14, P3.5, P5.57, P7.57
USB_ID: J3.1, P1.63
USB_OTG_N: J3.3, P1.69
USB_OTG_P: J3.2, P1.67
USB_VBUS_OTG: J3.5, P1.68
VDDA_GPO_PWR: P2.9

Notes on the sheet:
JX3
JX4
JX1
JX2
<-Might need to remove

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
Board: 2 copper layers, 98.3 x 106.9 mm, 11 parts (0 on the bottom side), 39 nets.

## KiCad design Mezzanine_Board.kicad_pcb

File readme.md:

#Cysat 1 Software Defined Radio Adapter Board

Currently only the breakout board has been designed, it should be easy to convert to the full board once proof of concept has been achievied.

Board: 2 copper layers, 4 parts (0 on the bottom side), 16 nets.

Parts:
P1, P2, P3, P4: CONN_02X50; BERGSTAK_100_PIN1_RIGHT

Connections:
/1V0_AVCC: P3.12, P3.16, P3.20, P3.24
/1V2_AVTT: P3.58, P3.62
/1V8: P2.41, P2.43, P2.47
/AD9361_GPO0: P4.2, P4.4
/ETH1_RX_CLK: P4.82, P4.90
/FMC_LA07_P: P3.71, P3.75
/FMC_LA08_N: P3.49, P3.61
/FMC_LA08_P: P3.53, P3.65
/FMC_LA19_P: P2.2, P2.4
/I2C2_SCL: P2.61, P2.63
/I2C2_SDA: P2.65, P2.67
/JTAG_TCK: P1.2, P1.4
/VADJ: P1.41, P1.43, P1.47, P2.7, P3.90, P3.92
/VIN_HDR: P1.81, P1.83, P1.85, P1.87, P2.22, P2.81, P2.83, P2.85, P2.87
GND: P1.9, P1.11, P1.29, P1.30, P1.31, P1.32, P1.42, P1.44, P1.45, P1.54, P1.56, P1.57, P1.59, P1.66, P1.68, P1.69, P1.71, P1.78, P1.80, P1.90, P1.92, P1.97, P1.99, P2.17, P2.19, P2.29, P2.30, P2.31, P2.32, P2.42, P2.44, P2.45, P2.54, P2.56, P2.57, P2.59, P2.66, P2.68, P2.69, P2.71, P2.78, P2.80, P2.90, P2.92, P2.97, P2.99, P3.9, P3.10, P3.11, P3.21, P3.22, P3.23, P3.33, P3.34, P3.35, P3.36, P3.45, P3.46, P3.47, P3.48, P3.57, P3.59, P3.60, P3.69, P3.72, P3.77, P3.78, P3.79, P3.89, P3.91, P3.98, P3.100, P4.9, P4.10, P4.11, P4.12, P4.21, P4.22, P4.23, P4.24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
unnamed: P3.2, P3.4

## Commit log

2018-07-24 Created new board, breakout
2018-07-25 Started work on breakout board
2018-07-25 Corrected and added basic pinout
2018-07-25 Basic pinout done and start of routing
2018-07-25 Added zones
2018-07-25 Started routing
2018-07-26 Work on schematic and traces
2018-07-26 Completed routing and added gerber
2018-07-27 Adding some of those personal touches
2018-07-27 cleaning up
2018-07-27 Added notch to avoid pc104 header
2018-07-29 update gerber
2018-07-30 Fixed gerber files
2018-07-31 Split into two boards and much futzing later the boards have been accepted
2018-09-15 Updating files
2019-04-30 completed layout w/o impedance matching
2019-05-03 'final' push
2019-05-03 final board v2, now with UART
2021-07-19 Files updated based on recent version sent to fab house
    This more recent revision fixes the FPGA connector issue and adds the LNA board to the backside. Board was changed from a 2-layer to a 4-layer board due to the additional RF components added.
2021-08-11 Updated to FPGA connector
    Rotated connectors to match what is on the board.
2021-08-20 Final updates that were sent for fabrication
2021-11-05 Board fix
    Board fix that was not uploaded to GitHub plus one slight modification to reduce the cutout from the TX/RX lines
2021-11-06 Minor updates
2021-11-06 some fixes
2021-11-06 Made fixes to schematic
    Swapped RX/TX pins, removed 3.3 and moved power to 5V rail. Added additional 5V pin, added RF GND pin to breakout. Addresses issues #1 and #2
2021-11-07 Updated schematic
    Cleaned up wires and re-did labels. Added additional grounds and verified pwr, TX and RX. Reference to Issues #1, #2, #3 and #5.
2021-11-16 Added power filter
2022-04-20 Updated board to KiCad 6, pushing previous changes made.
2022-04-21 Fixed grounding issue
2022-04-21 Auto stash before checking out "origin/master"
2022-04-21 renamed file
2023-02-23 Move files from main repo
2023-02-23 Moved from main repo
2023-02-23 Move from main repo
